## package/system/knulli-notice/Config.in
```kconfig
config BR2_PACKAGE_KNULLI_NOTICE
    bool "knulli-notice"
    help
      Knulli pdf notice
```
